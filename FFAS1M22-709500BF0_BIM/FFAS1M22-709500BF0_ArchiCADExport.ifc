Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2026-04-20T21:29:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 20 21:29:31 2026 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\d606287e-29ac-423b-b1f7-45876c9a8315\8ce34515-2065-4b6c-8fdc-cbafb546a7d2\ifc * Database version: 5507 * Database creation date: Mon Apr 20 21:29:24 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 20 21:29:24 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 20 21:29:24 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_348355
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FFAS1M22-709500BF0:FFAS1M22-709500BF0, FFAS1M22-709500BF0:FFAS1M22-709500BF0:348355
In: Level 1
Type - Material: American Standard - Brass - Chrome
Type - Pset_ElectricalDeviceCommon - NumberOfPoles: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: FFAS1M22-709500BF0
Pset_DistributionFlowElementCommon - Reference: FFAS1M22-709500BF0; sets with these values: 2
